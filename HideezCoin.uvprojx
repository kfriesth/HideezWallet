# Keil uVision project HideezCoin.uvprojx, settings and files
target HideezWallet (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: hideezWallet +hex
  AfterMake: d:\cygwin\bin\bash -c ./map2csv.sh
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\include\s110;.\include\nordic;.\src;.\src\coins;.\src\coins\protob;.\src\coins\trezor-crypto;D:\Keil5\ARM\Pack\ARM\CMSIS\4.1.0\CMSIS\Include
  asm misc: --li
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x20000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Source
    ./src/: system_nrf51.c main.c startup_nrf51.s console.c bt.c sha.c sound.c nvram.c random.c util.c ui.c
  group Coins
    ./src/coins/: address.c coins.c crypto.c dialog.c fsm.c messages.c reset.c signing.c storage.c transaction.c
  group Trezor-crypto
    ./src/coins/trezor-crypto/: base58.c bignum.c bip32.c curves.c ecdsa.c hmac.c rfc6979.c ripemd160.c secp256k1.c sha2.c
  group protobuf
    ./src/coins/protob/: messages.pb.c pb_decode.c pb_encode.c types.pb.c
